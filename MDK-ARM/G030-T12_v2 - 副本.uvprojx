# Keil uVision project G030-T12_v2 - 副本.uvprojx, settings and files
target G030-T12_v2 (6240000::V6.24::ARMCLANG)
  device: STM32G030K6Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: G030-T12_v2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32G030xx,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../Core/Src/u8g2;..\Core\Inc\HAL;..\Core\Inc\Service
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x1500
  memory RVCT10: RAM 0x20001500 size 0x500
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ../Core/Src/: oled_driver.c i2c.c PID.c main.c gpio.c adc.c spi.c tim.c stm32g0xx_it.c app_state_machine.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_adc.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_spi.c stm32g0xx_ll_pwr.c stm32g0xx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group u8g2
    ../Core/Src/u8g2/: mui.c mui.h mui_u8g2.c mui_u8g2.h u8g2.h u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_fonts.c u8g2_font.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8.h u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group Application/User/Core/HAL
    ../Core/Src/HAL/: adc_hal.c button_hal.c buzzer_hal.c encoder_hal.c pwm_hal.c timer_hal.c lm75_hal.c
  group Application/User/Core/Service
    ../Core/Src/Service/: config_service.c power_mgmt.c temp_control.c ui_service.c
software components: CMSIS:CORE 5.6.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
